<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_tx_dpsk</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>UHD TX DPSK</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ampl</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>label</key><value>Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>value</key><value>2.45e9</value></param>
<param><key>label</key><value>UHD Freq (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2.4e9</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>2.5e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>UHD Tx Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>address</value></param>
<param><key>label</key><value>IP Address</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>addr=192.168.10.3</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>8</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>C:\Users\ericj\Desktop\out.png</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>C:\Users\ericj\Senior-Design\Source\test_file.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>digital_dxpsk_demod_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>log</key><value>False</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
<param><key>sync_out</key><value>True</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>digital_dxpsk_mod</key>
<param><key>id</key><value>digital_dxpsk_mod_0</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>log</key><value>False</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Default Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.45e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Default Gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>tun_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>Transmit Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>tun_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>address</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_dxpsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_mod_0</source_block_id><sink_block_id>digital_dxpsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
